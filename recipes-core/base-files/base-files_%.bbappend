# Set custom hostname for Astrial H15 board
# System Electronics customization

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Force hostname to be set correctly
do_install:append() {
    echo "astrialh15" > ${D}${sysconfdir}/hostname

    # /boot in fstab: wic adds this entry, so the raw rootfs shipped in the
    # .swu lacks it and /boot stays unmounted after an update. By label,
    # since the UUID is generated by wic. nofail: an unmountable /boot must
    # not block boot.
    echo "LABEL=boot           /boot                vfat       defaults,nofail       0  0" \
        >> ${D}${sysconfdir}/fstab
}